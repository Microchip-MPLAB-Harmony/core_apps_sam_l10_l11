# Keil uVision project sam_l10_xpro_keil.uvprojx, settings and files
target sam_l10_xpro_keil (6180000::V6.18::ARMCLANG)
  device: ATSAML10E16A Microchip
  pack: Microchip.SAML10_DFP.3.9.116
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) IROM2(0x00400000,0x800) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: sam_l10_xpro_keil
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\sam_l10_xpro_keil;..\src\packs\ATSAML10E16A_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS
  scatter file: ..\src\config\sam_l10_xpro_keil\sam_l10_xpro_keil.sct
  group Harmony3
    ../src/config/sam_l10_xpro_keil/peripheral/nvmctrl/: plib_nvmctrl.h plib_nvmctrl.c
    ../src/config/sam_l10_xpro_keil/peripheral/evsys/: plib_evsys.h plib_evsys.c
    ../src/config/sam_l10_xpro_keil/peripheral/sercom/usart/: plib_sercom0_usart.h plib_sercom_usart_common.h plib_sercom0_usart.c
    ../src/config/sam_l10_xpro_keil/driver/usart/: drv_usart_definitions.h drv_usart.h
    ../src/config/sam_l10_xpro_keil/bsp/: bsp.h bsp.c
    ../src/config/sam_l10_xpro_keil/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h device_vectors.h user.h configuration.h sys_tasks.h initialization.c interrupts.c exceptions.c startup_keil.c tasks.c
    ../src/packs/ATSAML10E16A_DFP/component/: ac.h adc.h ccl.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h fuses.h gclk.h idau.h mclk.h nvmctrl.h opamp.h osc32kctrl.h oscctrl.h pac.h pm.h port.h ptc.h rstc.h rtc.h sercom.h supc.h tc.h tram.h trng.h wdt.h
    ../src/packs/ATSAML10E16A_DFP/instance/: ac.h adc.h ccl.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h fuses.h gclk.h idau.h mclk.h nvmctrl.h opamp.h osc32kctrl.h oscctrl.h pac.h pm.h port.h ptc.h rstc.h rtc.h sercom0.h sercom1.h sercom2.h supc.h tc0.h tc1.h tc2.h tram.h trng.h wdt.h
    ../src/packs/ATSAML10E16A_DFP/: saml10e16a.h
    ../src/packs/ATSAML10E16A_DFP/pio/: saml10e16a.h
    ../src/config/sam_l10_xpro_keil/peripheral/pm/: plib_pm.h plib_pm.c
    ../src/config/sam_l10_xpro_keil/peripheral/port/: plib_port.h plib_port.c
    ../src/config/sam_l10_xpro_keil/peripheral/clock/: plib_clock.h plib_clock.c
    ../src/config/sam_l10_xpro_keil/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm23.h mpu_armv8.h cachel1_armv7.h tz_context.h
    ../src/config/sam_l10_xpro_keil/driver/: driver.h driver_common.h
    ../src/config/sam_l10_xpro_keil/system/: system.h system_common.h system_module.h
    ../src/config/sam_l10_xpro_keil/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_l10_xpro_keil/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/: app.h main.c app.c
    ../src/config/sam_l10_xpro_keil/system/debug/: sys_debug.h
    ../src/config/sam_l10_xpro_keil/driver/usart/src/: drv_usart.c drv_usart_local.h
    ../src/config/sam_l10_xpro_keil/stdio/: keil_monitor.c
    ../src/config/sam_l10_xpro_keil/system/int/src/: sys_int.c
